options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_qtgui_toggle_switch_0
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: (2,0)
    initPressed: 'False'
    label: delay
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: CABLE Output
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: RS41-D_T1520425_20221006_1681MHz.wav
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate/baud_rate/2
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_crc16_async_bb_0
  id: digital_crc16_async_bb
  parameters:
    check: 'True'
    comment: |-
      polynomial 0x1021
      initial: 0xFFFF
      final xor: 0x0000
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class msg_blk(gr.basic_block):
          """data order reversing in packet
      OUT[0]=IN[n-1], OUT[1]=IN[n-2], ..., OUT[n-1]=IN[0]
      input message has to be u8 vector PDU"""
          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Reverse data order',
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_pdu)
               
          def handle_pdu(self, msg):
              # if PDU is not pair, drop and wait for new PDU
              if not pmt.is_pair(msg):
                  self.log.warn("PDU is not a pair, dropping")
                  return
              dict_in = pmt.car(msg)
              vector_in = pmt.cdr(msg)
              if not pmt.is_u8vector(vector_in):
                  self.log.warn("PDU doesn't content u8 vector, dropping")
                  return
              vect_size = pmt.length(vector_in)
              vector_out = pmt.make_u8vector(vect_size, 0)
              for x in range(vect_size):
                  pmt.u8vector_set(vector_out, vect_size-1 - x, pmt.u8vector_ref(vector_in, x))
              pdu_out = pmt.cons(dict_in, vector_out)
              self.message_port_pub(pmt.intern('out'), pdu_out)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class msg_blk(gr.basic_block):
          """data order reversing in packet
      OUT[0]=IN[n-1], OUT[1]=IN[n-2], ..., OUT[n-1]=IN[0]
      input message has to be u8 vector PDU"""
          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Reverse data order',
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_pdu)
               
          def handle_pdu(self, msg):
              # if PDU is not pair, drop and wait for new PDU
              if not pmt.is_pair(msg):
                  self.log.warn("PDU is not a pair, dropping")
                  return
              dict_in = pmt.car(msg)
              vector_in = pmt.cdr(msg)
              if not pmt.is_u8vector(vector_in):
                  self.log.warn("PDU doesn't content u8 vector, dropping")
                  return
              vect_size = pmt.length(vector_in)
              vector_out = pmt.make_u8vector(vect_size, 0)
              for x in range(vect_size):
                  pmt.u8vector_set(vector_out, vect_size-1 - x, pmt.u8vector_ref(vector_in, x))
              pdu_out = pmt.cons(dict_in, vector_out)
              self.message_port_pub(pmt.intern('out'), pdu_out)
  states: {}
- name: epy_block_soft_uart
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):

          """soft uart 8-bit character decoder
          parity: 0=NONE, 1=EVEN, 2=ODD
          separator is char or string to be inserted after last detected character"""

          def __init__(self, check_parity = 1, separator=""):  # only default arguments here
              gr.basic_block.__init__(
                  self,
                  name='software uart',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              self.check_parity = check_parity
              self.separator = separator
              self.rx_complete = False
              self.shift_reg = 0x0200

          def findParity(self, w): 
              y = w ^ (w >> 1) 
              y = y ^ (y >> 2) 
              y = y ^ (y >> 4) 
              y = y ^ (y >> 8) 
              y = y ^ (y >> 16) 
              # 1 means parity is odd else even 
              if (y & 1): 
                  return 1 
              else:
                  return 0

          def general_work(self, input_items, output_items):
              if (self.check_parity):
                  shiftOneBit = 0
              else:
                  shiftOneBit = 1
              x=0
              for new_bit in input_items[0]:
                  self.consume(0,1)
                  if ((self.shift_reg>>shiftOneBit) & 0x0003 == 0x0001) and new_bit!=0: #stop+start+stop bit
                      valid = True
                      if (self.check_parity):
                          valid = self.findParity(self.shift_reg>>2 & 0x1FF) == self.check_parity-1
                      if valid:
                          self.produce(0,1)
                          output_items[0][x] = ((self.shift_reg>>shiftOneBit)>>2) & 0xFF
                          x += 1
                          self.rx_complete = True
                      self.shift_reg = 0x0400
                  self.shift_reg >>= 1
                  if new_bit:  #insert new bit to shift register 
                      self.shift_reg |= 0x0400
                  if self.rx_complete and (self.shift_reg >= 0x07FF):   #receiving too much 1's
                      for ch in self.separator:    #insert separator characters if requested
                          self.produce(0,1)
                          output_items[0][x] = ord(ch)
                          x += 1
                      self.rx_complete = False
              return gr.WORK_CALLED_PRODUCE
    check_parity: '0'
    separator: ''''''
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("BLOCK_TYPE")
    v: pmt.intern("0x79")
  states: {}
- name: pdu_pdu_set_0_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("BLOCK_TYPE")
    v: pmt.intern("0x7A")
  states: {}
- name: pdu_pdu_set_0_1
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("BLOCK_TYPE")
    v: pmt.intern("0x76")
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 1,0
    ncols: '300'
    nrows: '32'
    samp_rate: baud_rate*2
    type: byte
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 2,0
    name: '"Manchester decoded"'
    ncols: '150'
    nrows: '32'
    samp_rate: baud_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 3,0
    name: '"RAW DATA BYTES"'
    ncols: '240'
    nrows: '30'
    samp_rate: '240'
    type: byte
    zmax: '127'
    zmin: '-128'
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 4,0
    name: '"REED-SOLOMON CORRECTED FRAME PAYLOAD"'
    ncols: '210'
    nrows: '30'
    samp_rate: '210'
    type: byte
    zmax: '127'
    zmin: '-128'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    label1: ''
    size: '512'
    srate: baud_rate*2
    type: float
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '0'
    gfpoly: '285'
    interleave: '1'
    nroots: '24'
    nsym: '8'
    prim: '1'
  states: {}
- name: satellites_pdu_head_tail_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '0'
    num: 0x28+2
  states: {}
- name: satellites_pdu_head_tail_0_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '0'
    num: 0x2A+2
  states: {}
- name: satellites_pdu_head_tail_0_0_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '0'
    num: 0x74+2
  states: {state: disabled}
- name: satellites_pdu_head_tail_1
  id: satellites_pdu_head_tail
  parameters:
    mode: '3'
    num: '2'
  states: {}
- name: satellites_pdu_head_tail_1_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '3'
    num: 2+0x28+4
  states: {}
- name: satellites_pdu_head_tail_1_0_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '3'
    num: 2+0x28+4+0x2A+4
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '234'
    sync: '"110110111101101111011011110110111101101101100100"'
    threshold: '1'
  states: {}
- name: trellis_viterbi_combined_xx_0
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: '64'
    comment: Manchester decoder
    dim: '2'
    final_state: '-1'
    fsm_args: '"c:\Documents and Settings\dieha\Documents\RS41-D\Manchester_encoder.fsm"'
    init_state: '0'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: '[0,0, 0,1, 1,0, 1,1]'
    type: f
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', trellis_viterbi_combined_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_delay_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_crc16_async_bb_0, out, blocks_message_debug_0, print]
- [epy_block_0, out, satellites_decode_rs_0, in]
- [epy_block_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0_0, out, satellites_pdu_head_tail_1, in]
- [epy_block_0_0, out, satellites_pdu_head_tail_1_0, in]
- [epy_block_0_0, out, satellites_pdu_head_tail_1_0_0, in]
- [epy_block_soft_uart, '0', blocks_unpack_k_bits_bb_0, '0']
- [epy_block_soft_uart, '0', qtgui_time_raster_sink_x_0_0_0, '0']
- [pdu_pdu_set_0, pdus, digital_crc16_async_bb_0, in]
- [pdu_pdu_set_0_0, pdus, digital_crc16_async_bb_0, in]
- [pdu_pdu_set_0_1, pdus, digital_crc16_async_bb_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_time_raster_sink_x_0_0_0_1, '0']
- [satellites_decode_rs_0, out, epy_block_0_0, in]
- [satellites_pdu_head_tail_0, out, pdu_pdu_set_0, pdus]
- [satellites_pdu_head_tail_0_0, out, pdu_pdu_set_0_0, pdus]
- [satellites_pdu_head_tail_0_0_0, out, pdu_pdu_set_0_1, pdus]
- [satellites_pdu_head_tail_1, out, satellites_pdu_head_tail_0, in]
- [satellites_pdu_head_tail_1_0, out, satellites_pdu_head_tail_0_0, in]
- [satellites_pdu_head_tail_1_0_0, out, satellites_pdu_head_tail_0_0_0, in]
- [satellites_sync_to_pdu_packed_0, out, epy_block_0, in]
- [trellis_viterbi_combined_xx_0, '0', epy_block_soft_uart, '0']
- [trellis_viterbi_combined_xx_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [variable_qtgui_toggle_switch_0, state, blocks_delay_0, dly]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
